# Keil uVision project F1_KEY.uvprojx, settings and files
target F1_KEY (6120000::V6.12::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F1_KEY +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ..\Drivers\User\Key;  ..\Drivers\User\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/key
    ../Drivers/User/Key/: key.c key.h
  group User/Led
    ../Drivers/User/LED/: led.c led.h
software components: CMSIS:CORE 5.2.0
